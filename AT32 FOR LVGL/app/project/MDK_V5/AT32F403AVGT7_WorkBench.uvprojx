# Keil uVision project AT32F403AVGT7_WorkBench.uvprojx, settings and files
target AT32F403AVGT7_WorkBench (6220000::V6.22::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403AVGT7_WorkBench +hex
  AfterMake: .\keil5_disp_size_bar.exe
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: AT32F403AVGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\app;..\ui_base;..\ui_show_page;..\common;..\interface;D:\Work Program\Keil_v5\ARM\Packs\LVGL\lvgl\9.4.0\demos;D:\Work Program\Keil_v5\ARM\Packs\LVGL\lvgl\8.4.0\demos;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c wk_crc.c wk_debug.c wk_spi.c wk_tmr.c wk_usart.c wk_wdt.c wk_xmc.c wk_dma.c wk_gpio.c wk_exint.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_xmc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group app
    ../app/: pc_handle.c beep_handle.c output_handle.c input_handle.c
  group common
    ../common/: iap.c soft_i2c.c PA45.c
  group interface
    ../interface/: Inf_beep.c Inf_key.c Inf_encoder.c Inf_lcd.c Inf_touch.c Inf_w25qxxx.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.2.0, Utilities:perf_counter:Core 2.5.5
