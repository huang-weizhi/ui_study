# Keil uVision project AT32F403AVGT7_WorkBench.uvprojx, settings and files
target AT32F403AVGT7_WorkBench (6220000::V6.22::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.4
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403AVGT7_WorkBench +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F403AVGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_crc.c wk_usart.c wk_gpio.c wk_debug.c flash.c iap.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_misc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
